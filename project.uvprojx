# Keil uVision project project.uvprojx, settings and files
target STM32F4-Discovery (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.7.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: IMU +hex
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,STM32F4XX,__ASSEMBLY__,KEIL_IDE,TM_DISCO_STM32F4_DISCOVERY,STM32F407VG
  c include: .\User;.\Libraries\STM32F4xx_StdPeriph_Driver\inc;.\Libraries\STM32F4xx_StdPeriph_Driver\src;.\Libraries\CMSIS\Device\ST\STM32F4xx\Include;.\Libraries\CMSIS\Device\ST\STM32F4xx\Source\Templates\arm;.\Libraries\CMSIS\Include;.\Libraries\TM_Libraries;.\10Dof_Code\inc;.\Discovery_board\inc;.\Libraries\fatfs;.\Libraries\fatfs\drivers;.\Libraries\fatfs\option
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group CMSIS
    ./Libraries/CMSIS/Device/ST/STM32F4xx/Include/: stm32f4xx.h system_stm32f4xx.h
  group Startup
    ./Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f40_41xxx.s
  group STD_Periph_Drivers
    ./Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_rcc.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_tim.c stm32f4xx_spi.c stm32f4xx_dma.c stm32f4xx_syscfg.c stm32f4xx_exti.c
    ./Libraries/STM32F4xx_StdPeriph_Driver/inc/: stm32f4xx_gpio.h
  group User
    ./User/: main.h main.c defines.h stm32f4xx_conf.h stm32f4xx_it.c stm32f4xx_it.h system_stm32f4xx.c
  group TM_Libraries
    ./Libraries/TM_Libraries/: tm_stm32f4_delay.c tm_stm32f4_delay.h tm_stm32f4_exti.c tm_stm32f4_exti.h tm_stm32f4_fatfs.c tm_stm32f4_fatfs.h tm_stm32f4_gpio.c tm_stm32f4_gpio.h tm_stm32f4_spi.c tm_stm32f4_spi.h tm_stm32f4_stdio.c tm_stm32f4_stdio.h tm_stm32f4_swo.c tm_stm32f4_swo.h tm_stm32f4_i2c.c tm_stm32f4_i2c.h
  group IMU
    ./10Dof_Code/src/: 10dof.c I2C.c
    ./10Dof_Code/inc/: 10dof.h I2C.h
  group Discovery_Board
    ./Discovery_board/inc/: led.h Timer.h I2C_improved.h
    ./Discovery_board/src/: led.c Timer.c I2C_improved.c
  group FatFs
    ./Libraries/fatfs/: diskio.c diskio.h ff.c ff.h ffconf.h integer.h
    ./Libraries/fatfs/option/: syscall.c unicode.c
    ./Libraries/fatfs/drivers/: fatfs_sd.c fatfs_sd.h
target STM32F429-Discovery (ARM-ADS)
  device: STM32F429ZITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.7.0
  cpu: IROM(0x08000000,0x200000) IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: project +hex
  c define: STM32F429_439xx,USE_STDPERIPH_DRIVER,STM32F4XX,__ASSEMBLY__,KEIL_IDE,TM_DISCO_STM32F429_DISCOVERY,__DBG_ITM
  c include: .\User;.\TM;..\00-STM32F429_LIBRARIES;..\00-STM32F4xx_STANDARD_PERIPHERAL_DRIVERS\STM32F4xx_StdPeriph_Driver\inc;..\00-STM32F4xx_STANDARD_PERIPHERAL_DRIVERS\STM32F4xx_StdPeriph_Driver\src;..\00-STM32F4xx_STANDARD_PERIPHERAL_DRIVERS\CMSIS\Device\ST\STM32F4xx\Include;..\00-STM32F4xx_STANDARD_PERIPHERAL_DRIVERS\CMSIS\Device\ST\STM32F4xx\Source\Templates\arm;..\00-STM32F4xx_STANDARD_PERIPHERAL_DRIVERS\CMSIS\Include
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
target STM32F401-Discovery (ARM-ADS)
  device: STM32F401VCTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.7.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: project +hex
  c define: STM32F401xx,USE_STDPERIPH_DRIVER,STM32F4XX,__ASSEMBLY__,KEIL_IDE,TM_DISCO_STM32F401_DISCOVERY
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
target Nucleo-F411 (ARM-ADS)
  device: STM32F411RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.7.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: project +hex
  c define: STM32F411xE,USE_STDPERIPH_DRIVER,STM32F4XX,__ASSEMBLY__,KEIL_IDE,TM_DISCO_NUCLEO_F411
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
target Nucleo-F401 (ARM-ADS)
  device: STM32F401RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.7.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x18000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: project +hex
  c define: STM32F401xx,USE_STDPERIPH_DRIVER,STM32F4XX,__ASSEMBLY__,KEIL_IDE,TM_DISCO_NUCLEO_F401
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
